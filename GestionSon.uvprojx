# Keil uVision project GestionSon.uvprojx, settings and files
target CibleSondeKEIL (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GestionSon +hex
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: .\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Principal
    ./Principal/: principal.c
  group GestionSon
    ./GestionSon/: bruitverre.asm GestionSon.s
  group Driver
    ./Driver/: ServiceJeuLaser.c DriverJeuLaser.lib
  group ServiceDFT
    ./ServiceDFT/: Signal_float.c CosSin_float.c DFT.c
  group ServiceDFT_Fract
    //netapp2/antunes/MATLAB/TP_CHTI/ASSEMBLEUR/1_SON+DFT/PjetKEL_GestionSon/ServiceDFT_Fract/: CosSin_Fract_1_15.asm Signal_4_12.asm
    ./ServiceDFT_Fract/: DFT_Fract.c
  group ModuleAffichage
    ./ModuleAffichage/: affichage_valise.o
target Simulation (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: GestionSon +hex
  c flags: Optim=5 OneElfS=1 v6LangP=3 wLevel=2
  c include: .\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
